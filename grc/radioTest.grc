options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '102'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rfsamprate
  id: variable
  parameters:
    value: 2048e3
  states: {}
- name: volume
  id: variable
  parameters:
    value: '20'
  states: {}
- name: FMReceiver_0
  id: FMReceiver
  parameters:
    audio_sample_rate: 48e3
    rf_samp_rate: rfsamprate
  states: {}
- name: audio
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: frequency*1000000
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rfsamprate
    sync: sync
    type: fc32
  states: {}

connections:
- [FMReceiver_0, '0', blocks_multiply_const_vxx_0, '0']
- [FMReceiver_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio, '1']
- [rtlsdr_source_0, '0', FMReceiver_0, '0']

metadata:
  file_format: 1
