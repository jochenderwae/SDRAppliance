options:
  parameters:
    category: SDRA DEMOD plugin
    generate_options: hb
    id: FMReceiver
    output_language: python
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: audio_sample_rate
  id: parameter
  parameters:
    label: audio_sample_rate
    type: eng_float
    value: 48e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: int(rf_samp_rate/quadrature)
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: padAudioLeft
  id: pad_sink
  parameters:
    label: audioLeft
    type: float
  states: {}
- name: padAudioRight
  id: pad_sink
  parameters:
    label: audioRight
    type: float
  states: {}
- name: padRFIn
  id: pad_source
  parameters:
    label: rfIn
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: rf_samp_rate
    type: eng_float
    value: 2048e3
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [padRFIn, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', padAudioLeft, '0']
- [rational_resampler_xxx_0, '0', padAudioRight, '0']

metadata:
  file_format: 1
