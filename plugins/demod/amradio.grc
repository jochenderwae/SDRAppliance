options:
  parameters:
    category: SDRA DEMOD plugin
    generate_options: hb
    id: AMReceiver
    output_language: python
  states: {}

blocks:
- name: quadrature
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: audio_sample_rate
  id: parameter
  parameters:
    label: audio_sample_rate
    type: eng_float
    value: 48e3
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 50e6
    type: float
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: int(rf_samp_rate/quadrature)
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: padAudioLeft
  id: pad_sink
  parameters:
    label: audioLeft
    type: float
  states: {}
- name: padAudioRight
  id: pad_sink
  parameters:
    label: audioRight
    type: float
  states: {}
- name: padRFIn
  id: pad_source
  parameters:
    label: rfIn
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: ''
    type: fff
  states: {}
- name: rf_samp_rate
  id: parameter
  parameters:
    label: rf_samp_rate
    type: eng_float
    value: 2048e3
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_1, '0', blocks_complex_to_mag_0, '0']
- [padRFIn, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_1, '0', padAudioLeft, '0']
- [rational_resampler_xxx_1, '0', padAudioRight, '0']

metadata:
  file_format: 1
